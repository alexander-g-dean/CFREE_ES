<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\YRDKRL78G13_Theremin_Demo.ewp</path>
  </project>
  <batchBuild />
</workspace>


