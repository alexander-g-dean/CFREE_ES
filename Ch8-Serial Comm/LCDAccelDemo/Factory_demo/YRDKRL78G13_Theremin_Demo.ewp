# IAR project YRDKRL78G13_Theremin_Demo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_include\; applilet3_src\; Glyph\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: applilet3_src\md_lnkr5f100le.xcl
  group applilet_src
    applilet3_src/: CG_int.c CG_int_user.c CG_it.c CG_it_user.c CG_main.c CG_port.c CG_port_user.c CG_serial.c CG_serial_user.c CG_system.c CG_system_user.c CG_systeminit.c CG_timer.c CG_timer_user.c CG_wdt.c CG_wdt_user.c
  group Glyph
    Glyph/: glyph.c glyph_register.c
  group Glyph/drivers
    Glyph/Drivers/: ST7579_LCD.c YRDKRL78_LCD.c
  group Glyph/fonts
    Glyph/Fonts/: bitmap_font.c font_8x16.c font_8x8.c font_helvr10.c font_logos.c font_winfreesystem14x16.c font_x5x7.c font_x6x13.c
  group user_src
    user_src/: lcd.c RDKRL78_spi.c
