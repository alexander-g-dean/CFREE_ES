# IAR project LCDDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: applilet3_src\; Glyph\; Glyph\Drivers\; Glyph\Fonts\; user_include\; RTC\
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group applilet_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_it.c r_cg_it_user.c r_cg_port.c r_cg_port_user.c r_cg_serial.c r_cg_serial_user.c r_cg_timer.c r_cg_timer_user.c r_main.c r_systeminit.c
  group Glyph
    Glyph/: glyph.c glyph_register.c
  group Glyph/Drivers
    Glyph/Drivers/: ST7579_LCD.c YRDKRL78_LCD.c
  group Glyph/Fonts
    Glyph/Fonts/: bitmap_font.c font_8x16.c font_8x8.c font_helvr10.c font_logos.c font_winfreesystem14x16.c font_x5x7.c font_x6x13.c
  group RTC
    RTC/: rtc_sched.c
  group user_src
    user_src/: lcd.c profile.c RDKRL78_spi.c region.c tasks.c
