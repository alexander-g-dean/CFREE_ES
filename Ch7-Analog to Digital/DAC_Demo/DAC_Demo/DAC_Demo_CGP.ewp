# IAR project DAC_Demo_CGP.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  XLINK.XclFile: applilet3_src\md_lnkr5f104pj.xcl
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_adc.c r_cg_adc_user.c r_cg_dac.c r_cg_dac_user.c
