# IAR project SwLEDDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  ICCRL78.IccLang: 0
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: applilet3_src\md_lnkr5f104pj.xcl
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  group applilet_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_main.c r_systeminit.c
